# IAR project GimbalCtr.ewp, settings and files
configuration GimbalCtr (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302xB ST STM32F302xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; STM32F302x8; ARM_MATH_CM4; MPL_LOG_NDEBUG=1; EMPL; MPU6500; EMPL_TARGET_STM32F4
  ICCARM.CCIncludePath2: ..\src\usr\; ..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\src\STM32USBHID\; ..\src\ComX\; ..\src\usr\ivnlib\core\driver\eMPL; ..\src\usr\ivnlib\core\driver\include; ..\src\usr\ivnlib\core\driver\stm32L; ..\src\usr\ivnlib\core\driver\stm32; ..\src\usr\ivnlib\core\eMPL-hal; ..\src\usr\ivnlib\core\mllite; ..\src\usr\ivnlib\core\mpl
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: GimbalCtr.bin
  ILINK.IlinkOutputFile: USB_GimbalCtr.out
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../EW_ARM_Main/: GimbalCtr_Main.eww
  group STM32_USB-FS-Device_Driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F30x_StdPeriph_Driver
    ../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_fmc.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group User
    ../src/usr/: adc.c adc.h AngSensor.c AngSensor.h arm_cortexM4lf_math.lib CCS.c CCS.h commonvalue.h Control.c Control.h CORDIC_math.c CORDIC_math.h datacalibrate .c datacalibrate.h device.c device.h EulerQuaternion.c EulerQuaternion.h factory.c factory.h FIFO.c FIFO.h filter.c filter.h flash.c flash.h IIC.c IIC.h IICtrancedata.c IICtrancedata.h IObit_remap.h kalman.c kalman.h led.c led.h MadgwickAHRS.c MadgwickAHRS.h MahonyAHRS.c MahonyAHRS.h main.c mpu6050.c mpu6050.h mpuheart.c mpuheart.h opamp.c opamp.h pctogimbal.c pctogimbal.h PID.c PID.h PWM.c PWM.h RLS.c RLS.h spi.c spi.h startup_stm32f30x.s stm32f30x_conf.h stm32f30x_it.c stm32f30x_it.h svpwm.c svpwm.h system_stm32f30x.c telecontroller.c telecontroller.h time.c time.h usart.c usart.h usart_data.c usart_data.h
  group User/ComX
    ../src/ComX/: ComX.c main.h platform_config.h STM32USBDevice_2WIRE.c SYSTIME.c UART32WIRE.c UartPack.c UartPack.h
  group User/STM32HIDUSB
    ../src/STM32USBHID/: hw_config.c hw_config.h usb_conf.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
