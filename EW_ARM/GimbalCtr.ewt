<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>GimbalCtr</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>EWARM</name>
  </group>
  <group>
    <name>STM32_USB-FS-Device_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32_USB-FS-Device_Driver\src\usb_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32_USB-FS-Device_Driver\src\usb_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32_USB-FS-Device_Driver\src\usb_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32_USB-FS-Device_Driver\src\usb_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32_USB-FS-Device_Driver\src\usb_regs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32_USB-FS-Device_Driver\src\usb_sil.c</name>
    </file>
  </group>
  <group>
    <name>STM32F3-Discovery</name>
  </group>
  <group>
    <name>STM32F30x_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_fmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_hrtim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_opamp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\STM32F30x_StdPeriph_Driver\src\stm32f30x_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>ComX</name>
      <file>
        <name>$PROJ_DIR$\..\src\ComX\ComX.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ComX\main.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ComX\platform_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ComX\STM32USBDevice_2WIRE.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ComX\SYSTIME.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ComX\UART32WIRE.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ComX\UartPack.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ComX\UartPack.h</name>
      </file>
    </group>
    <group>
      <name>STM32HIDUSB</name>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\hw_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\hw_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\usb_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\usb_desc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\usb_desc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\usb_endp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\usb_istr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\usb_istr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\usb_prop.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\usb_prop.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\usb_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\STM32USBHID\usb_pwr.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\src\usr\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\AngSensor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\AngSensor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\arm_cortexM4lf_math.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\CCS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\CCS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\commonvalue.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\Control.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\Control.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\CORDIC_math.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\CORDIC_math.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\datacalibrate .c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\datacalibrate.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\device.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\device.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\EulerQuaternion.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\EulerQuaternion.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\factory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\factory.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\FIFO.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\FIFO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\filter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\filter.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\IIC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\IIC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\IICtrancedata.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\IICtrancedata.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\IObit_remap.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\kalman.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\kalman.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\led.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\MadgwickAHRS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\MadgwickAHRS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\MahonyAHRS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\MahonyAHRS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\mpu6050.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\mpu6050.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\mpuheart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\mpuheart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\opamp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\opamp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\pctogimbal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\pctogimbal.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\PID.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\PID.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\PWM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\PWM.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\RLS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\RLS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\startup_stm32f30x.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\stm32f30x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\stm32f30x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\stm32f30x_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\svpwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\svpwm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\system_stm32f30x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\telecontroller.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\telecontroller.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\time.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\time.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\usart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\usart_data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usr\usart_data.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\EW_ARM_Main\GimbalCtr_Main.eww</name>
  </file>
</project>


